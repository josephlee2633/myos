# IAR project my_os.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxE GD GD32F20xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F20X_CL; HSE_VALUE=((uint32_t)8000000)
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS; ..\Drivers\Peripherals\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: my_os.bin
  ILINK.IlinkOutputFile: my_os.out
  ILINK.IlinkIcfFile: GD32F20xxE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Application/EWARM
    ../Drivers/CMSIS/IAR/: startup_gd32f20x_cl.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/: system_gd32f20x.c
  group MyOS
    ../MyOS/: main.c my_tiny_port.s
